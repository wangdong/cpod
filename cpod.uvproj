# Keil uVision project cpod.uvproj, settings and files
target cpod (MCS-51)
  device: nRF24LE1 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x03FF) XRAM2(0xFA00-0xFFFF) CLOCK(24000000) MODC2 MDU_R515
  output: cpod +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: EX_PROJ_LE1 NRF24LE1_32
  c include: .\params;.\lib\am2312;.\lib\ssd1306;.\lib\am2312;.\lib\nrf24\compiler\common;.\lib\nrf24\assertions;.\lib\nrf24\hal;.\lib\nrf24\hal\nrf24le1;.\lib\nrf24\hal\nrf24l01p;.\lib\nrf24\gazell\common;.\lib\nrf24\gazell\nrf24le1
  link misc: REMOVEUNUSED
  group app
    ./: main.c
  group ssd1306
    ./lib/ssd1306/: ssd1306.c
  group hal
    ./lib/nrf24/hal/: hal_delay.c
    ./lib/nrf24/hal/nrf24le1/: hal_rtc.c hal_clk.c hal_aes.c hal_flash.c hal_rng.c hal_spi.c hal_nrf_hw.c hal_w2.c
    ./lib/nrf24/hal/nrf24l01p/: hal_nrf.c
  group gzll
    ./lib/nrf24/gazell/common/: gzll.c gzp.c gzp_host.c
    ./lib/nrf24/gazell/nrf24le1/: gzp_host_le1.c gzll_timer_isr.c gzll_radio_isr.c gzll_mcu.c
  group am2312
    ./lib/am2312/: am2312.c
